# IAR project sam_a5d2_xplained_ultra_sw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN
  ICCARM.CCIncludePath2: ..\src\third_party\wolfssl; ..\src\third_party\wolfssl\wolfssl; ..\src; ..\src\config\sam_a5d2_xplained_ultra_sw; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xplained_ultra_sw.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xplained_ultra_sw\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/: arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h cpuid.h cryptocb.h curve25519.h curve448.h des3.h dh.h dsa.h ecc.h ed25519.h ed448.h error-crypt.h fe_448.h fe_operations.h fips_test.h ge_448.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h memory.h mem_track.h misc.h mpi_class.h mpi_superclass.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h rc2.h ripemd.h rsa.h selftest.h sha3.h signature.h sp.h sp_int.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_pkcs11.h wolfevent.h wolfmath.h settings.h aes.h sha.h sha256.h sha512.h wc_port.h
    ../src/third_party/wolfssl/wolfssl/: certs_test.h
  group Harmony3/Header Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/port/pic32/: pic32mz-crypt.h CryptoLib_cf_pb.h CryptoLib_ClearFlags_pb.h CryptoLib_Comp_pb.h CryptoLib_CondCopy_pb.h CryptoLib_CRT_pb.h CryptoLib_Div_pb.h CryptoLib_ExpMod_pb.h CryptoLib_FastCopy_pb.h CryptoLib_Fill_pb.h CryptoLib_Fmult_pb.h CryptoLib_GCD_pb.h CryptoLib_GF2NEccAdd_pb.h CryptoLib_GF2NEccConv_pb.h CryptoLib_GF2NEccDbl_pb.h CryptoLib_GF2NEccMul_pb.h CryptoLib_GF2NEcDsa_pb.h CryptoLib_Hardware_pb.h CryptoLib_Headers_pb.h CryptoLib_JumpTable_pb.h CryptoLib_mapping_pb.h CryptoLib_PrimeGen_pb.h CryptoLib_Rc_pb.h CryptoLib_RedMod_pb.h CryptoLib_Rng_pb.h CryptoLib_SelfTest_pb.h CryptoLib_Services_pb.h CryptoLib_Smult_pb.h CryptoLib_Square_pb.h CryptoLib_Swap_pb.h CryptoLib_typedef_pb.h CryptoLib_ZpEccAddSub_pb.h CryptoLib_ZpEccAdd_pb.h CryptoLib_ZpEccConv_pb.h CryptoLib_ZpEccDbl_pb.h CryptoLib_ZpEccMul_pb.h CryptoLib_ZpEccQuickDualMul_pb.h CryptoLib_ZpEcDsa_pb.h crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_crya_saml11.h crypt_ecc_ba414e.h crypt_ecc_pukcl.h crypt_pukcl_definitions.h crypt_pukcl_functions.h crypt_rng_hw.h crypt_rsa_pukcl.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h crypt_wolfcryptcb.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw
    ../src/config/sam_a5d2_xplained_ultra_sw/: config.h device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h user.h configuration.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/uart
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/uart/: plib_uart_common.h plib_uart1.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/pit
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/clk
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/pio
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/aic
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/peripheral/tc
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/driver
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/driver/usart
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/usart/: drv_usart_definitions.h drv_usart.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/crypto
    ../src/config/sam_a5d2_xplained_ultra_sw/crypto/: crypto.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/system
    ../src/config/sam_a5d2_xplained_ultra_sw/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/system/int
    ../src/config/sam_a5d2_xplained_ultra_sw/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/system/cache
    ../src/config/sam_a5d2_xplained_ultra_sw/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/system/dma
    ../src/config/sam_a5d2_xplained_ultra_sw/system/dma/: sys_dma.h sys_dma_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/system/debug
    ../src/config/sam_a5d2_xplained_ultra_sw/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/system/time
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_a5d2_xplained_ultra_sw/osal
    ../src/config/sam_a5d2_xplained_ultra_sw/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: sama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/instance
    ../src/packs/ATSAMA5D27_DFP/instance/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h gmac.h i2sc0.h i2sc1.h icm.h isc.h l2cc.h lcdc.h matrix0.h matrix1.h mcan0.h mcan1.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi0.h qspi1.h rstc.h rtc.h rxlp.h saic.h sckc.h sdmmc0.h sdmmc1.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi0.h spi1.h ssc0.h ssc1.h tc0.h tc1.h tdes.h trng.h twihs0.h twihs1.h uart0.h uart1.h uart2.h uart3.h uart4.h udphs.h wdt.h xdmac0.h xdmac1.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/: arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c cryptocb.c curve25519.c curve448.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c ed448.c error.c fe_448.c fe_low_mem.c fe_operations.c ge_448.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c rc2.c ripemd.c rsa.c sha3.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_dsp32.c sp_int.c sp_x86_64.c srp.c tfm.c wc_dsp.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c aes.c des3.c random.c sha.c sha256.c sha512.c
  group Harmony3/Source Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/port/pic32/: pic32mz-crypt.c crypt_aes_sam6149.c crypt_aes_u2238.c crypt_ecc_ba414e.c crypt_ecc_pukcl.c crypt_pukcl_functions.c crypt_rng_sam6334.c crypt_rng_u2242.c crypt_rsa_pukcl.c crypt_sam_u2803.c crypt_sha1_sam11105.c crypt_sha1_sam6156.c crypt_sha224_sam11105.c crypt_sha224_sam6156.c crypt_sha256_sam11105.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_tdes_sam6150.c crypt_wolfcryptcb.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw
    ../src/config/sam_a5d2_xplained_ultra_sw/: initialization.c interrupts.c cstartup.s fault_handlers.c tasks.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/uart
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/uart/: plib_uart1.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/pit
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/clk
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/pio
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/aic
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/peripheral/tc
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/driver/usart
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/usart/src/: drv_usart.c drv_usart_local.h
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/stdio
    ../src/config/sam_a5d2_xplained_ultra_sw/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/crypto
    ../src/config/sam_a5d2_xplained_ultra_sw/crypto/src/: crypto.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/system/int
    ../src/config/sam_a5d2_xplained_ultra_sw/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/system/cache
    ../src/config/sam_a5d2_xplained_ultra_sw/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/system/dma
    ../src/config/sam_a5d2_xplained_ultra_sw/system/dma/: sys_dma.c
  group Harmony3/Source Files/config/sam_a5d2_xplained_ultra_sw/system/time
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/src/: sys_time.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xplained_ultra_sw/: ddr.icf
